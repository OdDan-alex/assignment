File: My Projects.kicad_sch (KiCad schematic)
At the start: 4 parts

Commit message: commit
Parts:
- removed 1, 11: ~, symbol New_Library:NEW 7486
- added 1 (x2): ~, symbol New_Library:NEW 7486
